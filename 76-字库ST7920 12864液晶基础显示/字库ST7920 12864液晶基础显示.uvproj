# Keil uVision project 字库ST7920 12864液晶基础显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: 字库ST7920 12864液晶基础显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c 字库ST7920 12864液晶基础显示.c
