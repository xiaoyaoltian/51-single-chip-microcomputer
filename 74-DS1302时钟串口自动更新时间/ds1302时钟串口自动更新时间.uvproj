# Keil uVision project ds1302时钟串口自动更新时间.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: ds1302时钟串口自动更新时间 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DS1302.c main.c
