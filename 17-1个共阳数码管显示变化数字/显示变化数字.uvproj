# Keil uVision project 显示变化数字.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: 显示变化数字 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 显示变化数字.c
