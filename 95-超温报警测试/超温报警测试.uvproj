# Keil uVision project 超温报警测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: 超温报警测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 18b20.c delay.c main.c
