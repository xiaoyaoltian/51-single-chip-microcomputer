# Keil uVision project 双色点阵双色交替动态显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: 双色点阵双色交替动态显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 双色点阵双色交替动态显示.c
