# Keil uVision project 8位数码管静态显示其中之二.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: 8位数码管静态显示其中之二 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 8位数码管静态显示其中之二.c
