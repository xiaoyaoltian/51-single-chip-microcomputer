# Keil uVision project 24c02记忆开机次数.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: 24c02记忆开机次数 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c i2c.c delay.c display.c
